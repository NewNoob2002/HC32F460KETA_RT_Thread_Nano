# Keil uVision project HC32F460.uvprojx, settings and files
target HC32 (6160000::V6.16::ARMCLANG)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HC32F460 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB,__CORE_DEBUG,ARDUINO
  c include: ..\common;..\core\CMSIS\Include;..\driver\inc;..\source;..\source\include;..\rt-thread\bsp;..\rt-thread\components\finsh;..\rt-thread\include;..\rt-thread\include\libc;..\arduino;..\arduino\cores\arduino;..\arduino\cores\arduino\avr;..\arduino\variants\generic_hc32f460;..\arduino\cores\arduino\drivers\usart;..\arduino\cores\arduino\drivers\gpio;..\arduino\cores\arduino\drivers\adc;..\arduino\cores\arduino\drivers\irqn;..\arduino\cores\arduino\drivers\panic;..\arduino\cores\arduino\drivers\timera;..\arduino\cores\arduino\drivers\sysclock;..\arduino\libraries\HardwareI2c\src;..\arduino\libraries\SoftwareI2c\src;..\arduino\libraries\Timer0\src;..\arduino\libraries\EnhancedButton\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\linker\HC32F460xE.sct
  group common
    ./: startup_hc32f460.s
    ../common/: system_hc32f460.c
  group source
    ../source/: main.cpp
    ../rt-thread/bsp/: board.c
    ../source/src/: usart.c Led.cpp Key.cpp Task.cpp Begin.cpp Charger.cpp Fuelgauge.cpp powerControl.cpp
    ../source/include/: debug.h
  group core
    ../arduino/cores/arduino/: abi.cpp new.cpp Print.cpp Stream.cpp WInterrupts.cpp wiring_analog.cpp wiring_digital.cpp WMath.cpp WString.cpp itoa.c yield.c delay.c wiring_shift.c IPAddress.cpp
    ../arduino/cores/arduino/drivers/usart/: Usart.cpp usart_config.cpp usart_sync.cpp
    ../arduino/cores/arduino/drivers/adc/: adc.cpp adc_config.cpp
    ../arduino/cores/arduino/drivers/gpio/: addon_gpio.c
    ../arduino/cores/arduino/drivers/irqn/: irqn.cpp
    ../arduino/cores/arduino/drivers/panic/: ddl_assert.c panic.cpp
    ../arduino/cores/arduino/drivers/timera/: timera_config.cpp
    ../arduino/cores/arduino/drivers/sysclock/: systick.cpp sysclock.cpp sysclock_util.cpp
    ../arduino/variants/generic_hc32f460/: variant.cpp
    ../arduino/cores/arduino/avr/: dtostrf.c
  group driver
    ../driver/src/: hc32f460_pwc.c hc32f460_efm.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_utility.c hc32f460_usart.c hc32f460_keyscan.c hc32f460_gpio.c hc32f460_clk.c hc32f460_exint_nmi_swi.c hc32f460_adc.c hc32f460_timera.c hc32f460_rmu.c hc32f460_timer0.c hc32f460_i2c.c hc32f460_dmac.c hc32f460_spi.c hc32f460_sram.c
  group rtthread/libcpu
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group rtthread/src
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group library
    ../arduino/libraries/Timer0/src/: timer0_config.cpp Timer0.cpp
    ../arduino/libraries/HardwareI2c/src/: HardwareI2C.cpp
    ../arduino/libraries/SoftwareI2c/src/: SoftI2C.cpp
    ../arduino/libraries/EnhancedButton/src/: EnhancedButton.cpp
